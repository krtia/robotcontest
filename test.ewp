# IAR project test.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: adc12.c adc12.h delay.c delay.h DHT11.c DigtalTube.c DigtalTube.h DMA.c DMA.h Global.h GP2Y0A02.c GP2Y0A02.h Hall.c Hall.h HMC5883.c HMC5883.h I2C.c I2C.h IIC.c IIC.h L3G4200.c L3G4200.h LCD12864.c LCD12864.h main.c MMA8452.c MMA8452.h Motor.c Motor.h MPU6050.c MPU6050.h MPY.c MPY.h MSPMATHLIB_IAR_msp430_small.lib PhotoelectricEncoder.c PhotoelectricEncoder.h PID.c PID.h PWM.c PWM.h RotaryEncoder.c RotaryEncoder.h RTC.c RTC.h StepMotor.c StepMotor.h TimerA1.c TimerA1.h TimerA1_PWM.c TimerA1_PWM.h TimerB0.c TimerB0.h Traction.c Traction.h UART.c UART.h UCS.c UCS.h UltraSonic.c UltraSonic.h WDT.c WDT.h
